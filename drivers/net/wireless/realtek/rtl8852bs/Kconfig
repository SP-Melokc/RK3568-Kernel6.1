## drivers/net/wireless/realtek/rtl8852bs/Kconfig
```kconfig
config RTL8852BS
        tristate "Realtek 8852B SDIO WiFi"
        help
          Realtek 8852BS SDIO WiFi driver.
```
